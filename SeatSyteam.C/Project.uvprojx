# Keil uVision project Project.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\ASM;.\Library\inc;.\Library\src;.\stm32f10x_it.c;.\USER;.\System
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group ASM
    ./ASM/: startup_stm32f10x_hd.s
  group Library
    ./Library/src/: stm32f10x_rcc.c misc.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_usart.c
  group System
    ./System/: core_cm3.c system_stm32f10x.c system_stm32f10x.h stm32f10x.h core_cm3.h
  group USER
    ./USER/: main.c esp8266.h esp8266.c delay.c delay.h config.h json.h radar.h serial.h timer.h serial.c radar.c timer.c
    ./: json.c
  group stm32f10x_it
    ./stm32f10x_it.c/: stm32f10x_it.c stm32f10x_it.h
